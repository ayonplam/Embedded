# IAR project lpit_timer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\source; ..\MKE16Z4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpit_timer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: clock_config.c clock_config.h driver_lpit.c driver_lpit.h hal_lpit.c hal_lpit.h main.c
  group startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
