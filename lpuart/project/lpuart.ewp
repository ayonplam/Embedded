# IAR project lpuart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\MKE16Z4; ..\source\uart\Src; ..\source\uart\Inc; ..\source\srec\Src; ..\source\srec\Inc; ..\source\queue\Src; ..\source\queue\Inc; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lpuart.srec
  ILINK.IlinkOutputFile: lpuart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main.c
  group source/queue/Inc
    ../source/queue/Inc/: queue.h
  group source/queue/Src
    ../source/queue/Src/: queue.c
  group source/srec/Inc
    ../source/srec/Inc/: srec.h
  group source/srec/Src
    ../source/srec/Src/: srec.c
  group source/uart/Inc
    ../source/uart/Inc/: clock_config.h driver_lpuart.h hal_lpuart.h
  group source/uart/Src
    ../source/uart/Src/: clock_config.c driver_lpuart.c hal_lpuart.c
  group startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
