# IAR project MockProj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\MKE16Z4; ..\source; ..\source\ClockConfig; ..\source\button; ..\source\uart; ..\source\MiddleWare\queue; ..\source\MiddleWare\srec; ..\source\MiddleWare; ..\source\Bootloader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MockProj.srec
  ILINK.IlinkOutputFile: MockProj.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main.c manager.c manager.h
  group source/Bootloader
    ../source/Bootloader/: bootloader.c bootloader.h flash.c flash.h
  group source/button
    ../source/button/: driver_button.c driver_button.h hal_button.c hal_button.h
  group source/ClockConfig
    ../source/ClockConfig/: clock_config.c clock_config.h
  group source/MiddleWare
    ../source/MiddleWare/: common.h
  group source/MiddleWare/queue
    ../source/MiddleWare/queue/: queue.c queue.h
  group source/MiddleWare/srec
    ../source/MiddleWare/srec/: srec.c srec.h
  group source/uart
    ../source/uart/: driver_lpuart.c driver_lpuart.h hal_lpuart.c hal_lpuart.h
  group startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
